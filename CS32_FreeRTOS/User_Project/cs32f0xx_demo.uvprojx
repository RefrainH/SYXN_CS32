# Keil uVision project cs32f0xx_demo.uvprojx, settings and files
target cs32f0xx_start_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CS32F030C8T6 Chipsea
  pack: Chipsea.CS32F0xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: cs32f0xx_demo
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CS32F030
  c include: ..\Driver;..\User_Project;..\Core\Inc;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\App\Inc;..\App\Src;..\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: cs32f0xx_int.c main.c
    ../Core/Src/: freertos.c
  group Driver
    ../Driver/: systick.c tim.c usart.c bsp.c gpio.c iwdg.c
  group Rtos
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group App
    ../App/Inc/: about.h
    ../App/Src/: calibMeterMem.c log.c usrLib.c breaker.c currProtector.c currProtectorLongDelay.c currProtectorShortDelay.c currProtectorShortInstant.c memMgr.c watchDogMonitor.c
  group Bsp
    ../Bsp/: breakerAdc.c breakerIo.c
  group Doc
    ../Doc/: 01.功能说明.txt 02.修改记录.txt
software components: CMSIS:CORE 5.1.2, Device:HAL:ADC 1.0.0, Device:HAL:CRC 1.0.0, Device:HAL:DEBUG 1.0.0, Device:HAL:DMA 1.0.0, Device:HAL:EXTI 1.0.0, Device:HAL:FWDT 1.0.0, Device:HAL:Flash 1.0.0, Device:HAL:Framework 1.0.0, Device:HAL:GPIO 1.0.0, Device:HAL:I2C 1.0.0, Device:HAL:PMU 1.0.0, Device:HAL:RCU 1.0.0, Device:HAL:SPI 1.0.0, Device:HAL:SYSCFG 1.0.0, Device:HAL:TIM 1.0.0, Device:HAL:USART 1.0.0, Device:HAL:WWDT 1.0.0, Device:Startup 1.0.0
